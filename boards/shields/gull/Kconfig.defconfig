## boards/shields/gull/Kconfig.defconfig
```kconfig
# Copyright (c) 2021 The ZMK Contributors
# SPDX-License-Identifier: MIT

if SHIELD_GULL

config ZMK_KEYBOARD_NAME
    default "Gull"

endif
```
